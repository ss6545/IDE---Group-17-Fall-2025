# Keil uVision project Lab06.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lab06
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSPM0G3507__
  c include: C:\Users\Akshay Narang\Documents\IDE\cmpe460_mspm0_files-main\source;C:\Users\Akshay Narang\Documents\IDE\cmpe460_mspm0_files-main\lib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ..\..\source\ti\devices\msp\m0p\linker_files\keil\mspm0g3507.sct
  group Source Group 1
    ../../source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
    ./: main.c
  group lib
    ../../lib/lab6/: adc12.c adc12.h camera.c camera.h leds.c leds.h switches.c switches.h timers.c timers.h uart.c uart.h
    ../../lib/: uart_extras.c uart_extras.h
software components: CMSIS:CORE 5.6.0
